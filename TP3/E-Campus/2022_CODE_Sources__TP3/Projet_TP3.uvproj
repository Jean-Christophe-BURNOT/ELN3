# Keil uVision project Projet_TP3.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Essai_Uvision3
  c flags: Optimize=8 SizeSpeed=1
  link misc: NOOVERLAY
  group Programmes Source 1
    ./: Base_TP3.asm Lib_Base.asm Test_IO.C
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Proj_TP_SM3
  c flags: Optimize=8 SizeSpeed=1
  link misc: NOOVERLAY
