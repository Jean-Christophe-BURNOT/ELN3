# Keil uVision project TP2_ELN3.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP2_ELN3
  c flags: Optimize=8 SizeSpeed=1
  group Programmes source 1
    ./: CODE1_TP2.asm CODE2_TP2.asm CODE3_TP2.asm CODE4_TP2.asm CODE5_TP2.asm
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP_SM2
  c flags: Optimize=8 SizeSpeed=1
